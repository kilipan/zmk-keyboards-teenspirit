## boards/shields/teenspirit/Kconfig.defconfig
```kconfig
# SPDX-License-Identifier: MIT

if SHIELD_TEENSPIRIT

config ZMK_KEYBOARD_NAME
    default "teenspirit"

endif
```
